require zephyr-sdk.inc

SDK_ARCHIVE = "zephyr-sdk-${PV}_linux-${BUILD_ARCH}_gnu.tar.xz"

SRC_URI[x86_64.sha256sum] = "37a8c5b5569c2b482d39099c65fe3ddac4e43524996c731907e1e9f5818cbba7"
SRC_URI[aarch64.sha256sum] = "6e38018f70af5e90c18cc04c2f8ac5a91c99f5559b25692d1b0de328c3edb88a"
